# Keil uVision project STM32F407.uvprojx, settings and files
target STM32F407 (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F407 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,
  c include: ..\STM32\CMSIS\Device\ST\STM32F4xx\Include;..\STM32\CMSIS\Include;..\STM32\STM32F4xx_StdPeriph_Driver\inc;..\MY;..\Drive\Include;..\App
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group MY
    ../App/: main.c task1.c
    ../MY/: stm32f4xx_it.c stm32f4xx_conf.h
  group Drive
    ../Drive/Source/: delay.c
    ../App/: alert.h encoder.h infrared.h motor.h mpu6050.h openmv.h pid.h state_machine.h syn6658.h syn6658.c state_machine.c pid.c openmv.c mpu6050.c motor.c infrared.c encoder.c alert.c
  group STM32
    ../STM32/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
    ../STM32/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../STM32/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_tim.c stm32f4xx_usart.c
